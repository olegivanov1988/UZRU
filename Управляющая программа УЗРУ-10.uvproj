# Keil uVision project Управляющая программа УЗРУ-10.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: MDR1986BE1T Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) CPUTYPE("Cortex-M1") CLOCK(144000000) ELITTLE
  output: UZRUFirm +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c include: .\Device;.\Initialization;.\Protocols;.\Application;.\Subsystems;.\Drivers;.\Board;.\Device\CMSIS\CM1\DeviceSupport\MDR1986VE1T\inc;.\Device\CMSIS\CM1\CoreSupport;.\Device\CMSIS\CM1\DeviceSupport\MDR1986VE1T\startup;.\General;.\EasyTCPIP;.\Faults;.\Display
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group Application
    ./Application/: main.c
  group Device
    ./Device/CMSIS/CM1/DeviceSupport/MDR1986VE1T/inc/: MDR1986VE1T.h
    ./Device/CMSIS/CM1/DeviceSupport/MDR1986VE1T/startup/arm/: startup_MDR1986VE1T.s
    ./Device/CMSIS/CM1/CoreSupport/: core_cm1.h core_cmFunc.h core_cmInstr.h
  group Initialization
    ./Initialization/: Init1986VE1T.c InitADC.c InitDAC.c InitEEPROM.c InitPORTA.c InitPORTB.c InitPORTC.c InitPORTD.c InitPORTE.c InitPORTF.c InitRST_CLK.c InitTIMER1.c InitTIMER2.c InitTIMER3.c InitTIMER4.c Init1986VE1T.h InitADC.h InitDAC.h InitEEPROM.h InitPORTA.h InitPORTB.h InitPORTC.h InitPORTD.h InitPORTE.h InitPORTF.h InitRST_CLK.h InitTIMER1.h InitTIMER2.h InitTIMER3.h InitTIMER4.h
  group Drivers
    ./Drivers/: DriverMDR32_ADC.c DriverMDR32_DAC.c DriverMDR32_EEPROM.c DriverMDR32_PORT.c DriverMDR32_RST_CLK.c DriverMDR32_TIMER.c DriverMDR32_UART.c DriverMDR32_ADC.h DriverMDR32_DAC.h DriverMDR32_EEPROM.h DriverMDR32_PORT.h DriverMDR32_RST_CLK.h DriverMDR32_TIMER.h DriverMDR32_UART.h DriverMDR1986VE1T.c DriverMDR1986VE1T.h
  group Subsystems
    ./Subsystems/: Subsystems.c ManualOperator.h ManualOperator.c EEPROM.c EEPROM.h References.c References.h Measurements.c Measurements.h Calibrations.c Calibrations.h Faults.c Faults.h Relays.c Relays.h ChargeController.c ChargeController.h PayloadController.c PayloadController.h PrechargeController.c PrechargeController.h ConvContactorController.c ConvContactorController.h UZRU10A.c UZRU10A.h
  group Board
    ./Board/: Board.c Board.h
  group General
    ./General/: MemAPI.c TimeControl.c
  group Display
    ./Display/: Display.c Display.h Keyboard.c Keyboard.h Menu.c Menu.h
  group Interrupts
    ./Interrupts/: ADC.c Timer.c
